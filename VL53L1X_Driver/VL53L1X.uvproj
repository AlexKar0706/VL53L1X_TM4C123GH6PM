# Keil uVision project VL53L1X.uvproj, settings and files
target VL53L1X (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: VL53L1X
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s main.c
  group I2C
    ./I2C/: i2c.c pll.c
  group VL53L1X_API
    ./VL53L1X_API/: vl53l1_platform.c VL53L1X_api.c VL53L1X_calibration.c
  group SSD1306
    ./SSD1306/: SSD1306.c
